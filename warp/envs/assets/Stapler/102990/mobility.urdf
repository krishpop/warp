Commit message: added new allegro partnet mob grasps, and symlink assets

File: warp/envs/assets/Stapler/102990/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_20c5096ea98cc955920de219c00d1c3b, 4 links, 3 joints
Joints:
- joint joint_0: type revolute -> fixed
