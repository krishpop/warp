Commit message: moved dispenser joint continuous -> revolute

File: warp/envs/assets/Dispenser/101517/mobility.urdf (robot description, URDF)
Before this commit: robot partnet_76221d93ba6f391876c18e71fd49c4dc, 4 links, 3 joints
Joints:
- joint joint_1: type continuous -> revolute
